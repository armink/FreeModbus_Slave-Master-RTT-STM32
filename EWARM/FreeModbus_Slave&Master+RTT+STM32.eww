<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FreeModbus_Slave&amp;Master+RTT+STM32.ewp</path>
  </project>
  <batchBuild/>
</workspace>


